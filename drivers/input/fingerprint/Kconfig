## drivers/input/fingerprint/Kconfig
```kconfig
source "drivers/input/fingerprint/goodix_fp/Kconfig"
source "drivers/input/fingerprint/betterlife_fp/Kconfig"
```
